# Keil uVision project stm32-.uvprojx, settings and files
target stm32- (6230000::V6.23::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32- +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./lib_user/bsp/bsp_encode;./lib_user/bsp/bsp_motor;./lib_user/bsp/bsp_mpu6050;./lib_user/bsp/encode_motor;./lib_user/module/buzzer;./lib_user/module/pid;./lib_user/module/soft_timer;./lib_user/module/uart;./lib_user/config_user;./lib_user/Fusion-main/Fusion;./lib_user/bsp/bsp_oled;./lib_user/module/upacker/c
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group bsp
    ./lib_user/bsp/bsp_mpu6050/: MPU6050.c MPU6050.h
    ./lib_user/bsp/encode_motor/: encode_motor.c encode_motor.h
    ./lib_user/bsp/bsp_motor/: bsp_motor.c bsp_motor.h
    ./lib_user/bsp/bsp_encode/: bsp_encode.c bsp_encode.h
    ./lib_user/bsp/bsp_oled/: oled.c oled.h oledfont.c oledfont.h
  group moduel
    ./lib_user/module/pid/: positional_pid.c positional_pid.h
    ./lib_user/module/soft_timer/: soft_timer.c soft_timer.h
    ./lib_user/module/uart/: print.c print.h
    ./lib_user/Fusion-main/Fusion/: Fusion.h FusionAhrs.c FusionAhrs.h FusionAxes.h FusionCalibration.h FusionCompass.c FusionCompass.h FusionConvention.h FusionMath.h FusionOffset.c FusionOffset.h
    ./lib_user/module/upacker/c/: upacker.c upacker.h
  group APP
    ./lib_user/config_user/: main_config.h task.h task.c APP_PID.h APP_PID.c app_car_control.c app_car_control.h APP_beep_led_key.c APP_beep_led_key.h APP_uart.c APP_uart.h
software components: CMSIS:CORE 6.1.0
